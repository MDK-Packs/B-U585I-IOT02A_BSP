# Keil uVision project Blinky.uvprojx, settings and files
target B-U585I-IOT02A (6210000::V6.21::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\RTE\Device\STM32U585AIIx\stm32u585xx_flash.sct
  group App
    ./: Blinky.c
  group Documentation
    ./: README.md
  group :STM32CubeMX:Common Sources
    ./Board/B-U585I-IOT02A/STM32CubeMX/Src/: main.c stm32u5xx_it.c
    ./Board/B-U585I-IOT02A/STM32CubeMX/Inc/: stm32u5xx_it.h
    ./Board/B-U585I-IOT02A/STM32CubeMX/: STM32CubeMX.ioc
software components: CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Components:IIS2MDC 1.1.2, Board Support:Components:ISM330DHCX 1.1.3, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:Motion Sensors 1.1.0, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube Framework:STM32CubeMX 2.0.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:EXTI 1.3.0, Device:STM32Cube HAL:Flash 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:ICACHE 1.3.0, Device:STM32Cube HAL:MDF 1.3.0, Device:STM32Cube HAL:OSPI 1.3.0, Device:STM32Cube HAL:PCD 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SPI 1.3.0, Device:STM32Cube HAL:SRAM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:DLYB 1.3.0, Device:STM32Cube LL:GPIO 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UCPD 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.3.0
