# Keil uVision project Platform.uvprojx, settings and files
target B-U585I-IOT02A (6160000::V6.16::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT7: RAM 0x20040000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040800 size 0x7f800
  scatter file: .\stm32u585.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: arduino.c arduino.h retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32U585AIIx/STCubeGenerated/Src/: main.c stm32u5xx_it.c
    ./RTE/Device/STM32U585AIIx/STCubeGenerated/Inc/: stm32u5xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32U585AIIx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Components:IIS2MDC 1.1.0, Board Support:Components:ISM330DLC 1.1.0, Board Support:Drivers:BUS 1.0.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:Motion Sensors 1.0.0, CMSIS Driver:VIO:Board 1.2.0, Device:STM32Cube HAL:Common 1.0.2, Device:STM32Cube HAL:Cortex 1.0.2, Device:STM32Cube HAL:DMA 1.0.2, Device:STM32Cube HAL:EXTI 1.0.2, Device:STM32Cube HAL:Flash 1.0.2, Device:STM32Cube HAL:GPIO 1.0.2, Device:STM32Cube HAL:I2C 1.0.2, Device:STM32Cube HAL:ICACHE 1.0.2, Device:STM32Cube HAL:IRDA 1.0.2, Device:STM32Cube HAL:MDF 1.0.2, Device:STM32Cube HAL:OSPI 1.0.2, Device:STM32Cube HAL:PCD 1.0.2, Device:STM32Cube HAL:PWR 1.0.2, Device:STM32Cube HAL:RCC 1.0.2, Device:STM32Cube HAL:SPI 1.0.2, Device:STM32Cube HAL:UART 1.0.2, Device:STM32Cube LL:Common 1.0.2, Device:STM32Cube LL:DLYB 1.0.2, Device:STM32Cube LL:GPIO 1.0.2, Device:STM32Cube LL:PWR 1.0.2, Device:STM32Cube LL:RCC 1.0.2, Device:STM32Cube LL:UCPD 1.0.2, Device:STM32Cube LL:UTILS 1.0.2, Device:Startup 1.0.2
