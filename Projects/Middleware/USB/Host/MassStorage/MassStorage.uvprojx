# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\RTE\Device\STM32U585AIIx\stm32u585xx_flash.sct
  group Source
    ./: MassStorage.c USBH_MSC.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./Board/B-U585I-IOT02A/STM32CubeMX/Src/: main.c stm32u5xx_it.c
    ./Board/B-U585I-IOT02A/STM32CubeMX/Inc/: stm32u5xx_it.h
    ./Board/B-U585I-IOT02A/STM32CubeMX/: STM32CubeMX.ioc
target Release (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: as above
  output: MassStorage
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\RTE\Device\STM32U585AIIx\stm32u585xx_flash.sct
  link misc: --diag_suppress=L6314
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, Board Support:Components:EMW3080 2.1.12, Board Support:Components:IIS2MDC 1.1.2, Board Support:Components:ISM330DHCX 1.1.3, Board Support:Components:TCPP0203 1.2.2, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:Motion Sensors 1.1.0, Board Support:Drivers:USB PD 1.1.0, File System:CORE 6.16.2, File System:CORE 6.16.2, File System:Drive:USB 6.16.2, USB:CORE 6.16.2, USB:CORE 6.16.2, USB:Host 6.16.2, USB:Host:MSC 6.16.2, CMSIS Driver:SPI 1.1.0, CMSIS Driver:USART 1.2.0, CMSIS Driver:USB Host:Full-speed 1.0.0, CMSIS Driver:VIO:Board 1.2.0, CMSIS Driver:WiFi:EMW3080 1.0.0, Device:STM32Cube HAL:ADC 1.2.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:EXTI 1.2.0, Device:STM32Cube HAL:Flash 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:HCD 1.2.0, Device:STM32Cube HAL:I2C 1.2.0, Device:STM32Cube HAL:ICACHE 1.2.0, Device:STM32Cube HAL:IRDA 1.2.0, Device:STM32Cube HAL:MDF 1.2.0, Device:STM32Cube HAL:OSPI 1.2.0, Device:STM32Cube HAL:PCD 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:RNG 1.2.0, Device:STM32Cube HAL:RTC 1.2.0, Device:STM32Cube HAL:SPI 1.2.0, Device:STM32Cube HAL:Smartcard 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:STM32Cube HAL:USART 1.2.0, Device:STM32Cube LL:Common 1.2.0, Device:STM32Cube LL:DLYB 1.2.0, Device:STM32Cube LL:GPIO 1.2.0, Device:STM32Cube LL:PWR 1.2.0, Device:STM32Cube LL:RCC 1.2.0, Device:STM32Cube LL:UCPD 1.2.0, Device:STM32Cube LL:UTILS 1.2.0, Device:Startup 1.2.0
